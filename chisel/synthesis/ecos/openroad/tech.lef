VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

UNITS
  DATABASE MICRONS 2000 ;
END UNITS

SITE core7
  CLASS CORE ;
  SIZE 0.38 BY 2.8 ;
END core7

END LIBRARY
